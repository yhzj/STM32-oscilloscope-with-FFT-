# Keil uVision project SD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\code;..\dsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dma.c
  group STAR
    ../Startup/: startup_stm32f10x_cl.s
  group code
    ../code/: main.c stm32f10x_it.c ini.c LCD.c touch.c fft.c
  group dsp
    ../dsp/: cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
